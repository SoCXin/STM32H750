# IAR project Project.ewp, settings and files
configuration STM32H745I_Discovery_CM7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM7
  ICCARM.CCIncludePath2: ..\user\CM7\include; ..\user\ST\STM32H7xx_HAL_Driver\Inc; ..\user\ST\BSP\STM32H745I-Discovery; ..\user\ST\BSP\Components\Common; ..\Source\include; ..\Source\portable\IAR\ARM_CM4F; ..\user\ST\CMSIS\Device\ST\STM32H7xx\Include; ..\user
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\user\CM7\include
  OBJCOPY.OOCOutputFile: STM32H745I_Discovery_CM7.hex
  ILINK.IlinkOutputFile: STM32H745I_Discovery_CM7.out
  ILINK.IlinkIcfFile: ..\user\stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../user/: startup_stm32h745xx.s
  group Application/User/CM7
    ../user/CM7/include/: FreeRTOSConfig.h
    ../user/CM7/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group FreeRTOS_Source
    ../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Source/include
    ../Source/include/: event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group FreeRTOS_Source/portable/IAR
    ../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS_Source/portable/MemMang
    ../Source/portable/MemMang/: heap_4.c
  group ST_code/BSP/STM32H745I_Discovery
    ../user/ST/BSP/STM32H745I-Discovery/: stm32h745i_discovery.c
  group ST_code/CMSIS
    ../user/: system_stm32h7xx.c
  group ST_code/STM32H7xx_HAL_Driver
    ../user/ST/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
