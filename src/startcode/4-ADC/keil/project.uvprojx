# Keil uVision project project.uvprojx, settings and files
target QITAS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c include: ..\..\STM32H7xx_HAL_Driver\CORE;..\USER;..\..\SYS\delay;..\..\SYS\sys;..\..\SYS\usart;..\..\STM32H7xx_HAL_Driver\Inc;..\..\BSP\LED;..\..\BSP\KEY;..\..\BSP\TIMER;..\..\BSP\OLED;..\..\BSP\ADC;..\..\BSP\DAC
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ../USER/: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../../STM32H7xx_HAL_Driver/CORE/: startup_stm32h750xx.s core_cm7.h
  group SYSTEM
    ../../SYS/delay/: delay.c
    ../../SYS/sys/: sys.c
    ../../SYS/usart/: usart.c
  group HALLIB
    ../../STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
  group HARDWARE
    ../../BSP/LED/: led.c
    ../../BSP/KEY/: key.c
    ../../BSP/TIMER/: timer.c
    ../../BSP/OLED/: oled.c
    ../../BSP/DAC/: dac.c
    ../../BSP/ADC/: adc.c
